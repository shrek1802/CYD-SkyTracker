#pragma once
// Independently authored ICAO aircraft-type lookup used by the photo panel.
// Exact model where possible; type photos are ALWAYS labelled representative.
#include <cctype>
#include <cstring>

namespace AircraftTypePhoto {
struct Entry { const char* code; const char* model; const char* commonsCategory; };
static constexpr Entry kModels[] = {
    {"A318", "Airbus A318", "Airbus A318"},
    {"A319", "Airbus A319", "Airbus A319"},
    {"A320", "Airbus A320", "Airbus A320"},
    {"A20N", "Airbus A320neo", "Airbus A320neo"},
    {"A321", "Airbus A321", "Airbus A321"},
    {"A21N", "Airbus A321neo", "Airbus A321neo"},
    {"BCS1", "Airbus A220-100", "Airbus A220-100"},
    {"BCS3", "Airbus A220-300", "Airbus A220-300"},
    {"A332", "Airbus A330-200", "Airbus A330-200"},
    {"A333", "Airbus A330-300", "Airbus A330-300"},
    {"A339", "Airbus A330-900neo", "Airbus A330-900neo"},
    {"A359", "Airbus A350-900", "Airbus A350-900"},
    {"A35K", "Airbus A350-1000", "Airbus A350-1000"},
    {"A388", "Airbus A380-800", "Airbus A380-800"},
    {"B737", "Boeing 737-700", "Boeing 737-700"},
    {"B738", "Boeing 737-800", "Boeing 737-800"},
    {"B739", "Boeing 737-900", "Boeing 737-900"},
    {"B38M", "Boeing 737 MAX 8", "Boeing 737 MAX 8"},
    {"B39M", "Boeing 737 MAX 9", "Boeing 737 MAX 9"},
    {"B744", "Boeing 747-400", "Boeing 747-400"},
    {"B748", "Boeing 747-8", "Boeing 747-8"},
    {"B752", "Boeing 757-200", "Boeing 757-200"},
    {"B753", "Boeing 757-300", "Boeing 757-300"},
    {"B763", "Boeing 767-300", "Boeing 767-300"},
    {"B764", "Boeing 767-400", "Boeing 767-400"},
    {"B772", "Boeing 777-200", "Boeing 777-200"},
    {"B77W", "Boeing 777-300ER", "Boeing 777-300ER"},
    {"B788", "Boeing 787-8", "Boeing 787-8"},
    {"B789", "Boeing 787-9", "Boeing 787-9"},
    {"B78X", "Boeing 787-10", "Boeing 787-10"},
    {"E170", "Embraer 170", "Embraer 170"},
    {"E175", "Embraer 175", "Embraer 175"},
    {"E190", "Embraer 190", "Embraer 190"},
    {"E195", "Embraer 195", "Embraer 195"},
    {"E290", "Embraer E190-E2", "Embraer E190-E2"},
    {"E295", "Embraer E195-E2", "Embraer E195-E2"},
    {"AT72", "ATR 72", "ATR 72"},
    {"AT76", "ATR 72-600", "ATR 72-600"},
    {"DH8D", "De Havilland Canada Dash 8-400", "De Havilland Canada Dash 8-400"},
    {"CRJ2", "Bombardier CRJ200", "Bombardier CRJ200"},
    {"CRJ7", "Bombardier CRJ700", "Bombardier CRJ700"},
    {"CRJ9", "Bombardier CRJ900", "Bombardier CRJ900"},
    {"F406", "Reims-Cessna F406 Caravan II", "Reims-Cessna F406"},
    {"BE20", "Beechcraft King Air 200", "Beechcraft King Air"},
    {"BE30", "Beechcraft King Air 300", "Beechcraft King Air"},
    {"B190", "Beechcraft 1900D", "Beechcraft 1900"},
    {"C402", "Cessna 402", "Cessna 402"},
    {"C404", "Cessna 404 Titan", "Cessna 404 Titan"},
    {"F2TH", "Dassault Falcon 2000", "Dassault Falcon 2000"},
    {"P68", "Partenavia P.68", "Partenavia P.68"},
    {"C172", "Cessna 172", "Cessna 172"},
    {"C182", "Cessna 182", "Cessna 182"},
    {"C208", "Cessna 208 Caravan", "Cessna 208 Caravan"},
    {"PA28", "Piper PA-28", "Piper PA-28"},
    {"PC12", "Pilatus PC-12", "Pilatus PC-12"},
    {"C25A", "Cessna Citation CJ2", "Cessna Citation CJ2"},
    {"C56X", "Cessna Citation Excel", "Cessna Citation Excel"},
    {"GLF5", "Gulfstream V", "Gulfstream V"},
    {"GLF6", "Gulfstream G650", "Gulfstream G650"},
    {"CL60", "Bombardier Challenger 600", "Bombardier Challenger 600"},
    {"LJ45", "Learjet 45", "Learjet 45"},
    {"B77F", "Boeing 777F", "Boeing 777F"},
    {"A400", "Airbus A400M", "Airbus A400M"},
    {"C130", "Lockheed C-130 Hercules", "Lockheed C-130 Hercules"},
    {"C17", "Boeing C-17 Globemaster III", "Boeing C-17 Globemaster III"},
    {"E145", "Embraer ERJ 145", "Embraer ERJ 145"},
    {"SF34", "Saab 340", "Saab 340"},
    {"C152", "Cessna 152", "Cessna 152"},
    {"DA40", "Diamond DA40", "Diamond DA40"},
    {"DA42", "Diamond DA42", "Diamond DA42"},
    {"SR22", "Cirrus SR22", "Cirrus SR22"},
    {"EC35", "Eurocopter EC135", "Eurocopter EC135"},
    {"A139", "Leonardo AW139", "Leonardo AW139"},
    {"R44", "Robinson R44", "Robinson R44"},
    {"S76", "Sikorsky S-76", "Sikorsky S-76"},
    {"CL35", "Bombardier Challenger 350", "Bombardier Challenger 350"},
    {"A306", "Airbus A300-600", "Airbus A300-600"},
    {"A310", "Airbus A310", "Airbus A310"},
    {"A343", "Airbus A340-300", "Airbus A340-300"},
    {"A345", "Airbus A340-500", "Airbus A340-500"},
    {"A346", "Airbus A340-600", "Airbus A340-600"},
    {"A338", "Airbus A330-800neo", "Airbus A330-800neo"},
    {"B712", "Boeing 717-200", "Boeing 717-200"},
    {"B733", "Boeing 737-300", "Boeing 737-300"},
    {"B734", "Boeing 737-400", "Boeing 737-400"},
    {"B735", "Boeing 737-500", "Boeing 737-500"},
    {"B736", "Boeing 737-600", "Boeing 737-600"},
    {"B742", "Boeing 747-200", "Boeing 747-200"},
    {"B743", "Boeing 747-300", "Boeing 747-300"},
    {"B762", "Boeing 767-200", "Boeing 767-200"},
    {"B773", "Boeing 777-300", "Boeing 777-300"},
    {"B77L", "Boeing 777-200LR", "Boeing 777-200LR"},
    {"E75L", "Embraer 175", "Embraer 175"},
    {"E120", "Embraer EMB 120 Brasilia", "Embraer EMB 120 Brasilia"},
    {"E35L", "Embraer Legacy 600", "Embraer Legacy 600"},
    {"E55P", "Embraer Phenom 300", "Embraer Phenom 300"},
    {"E50P", "Embraer Phenom 100", "Embraer Phenom 100"},
    {"E550", "Embraer Legacy 500", "Embraer Legacy 500"},
    {"C25B", "Cessna Citation CJ3", "Cessna Citation CJ3"},
    {"C25C", "Cessna Citation CJ4", "Cessna Citation CJ4"},
    {"C510", "Cessna Citation Mustang", "Cessna Citation Mustang"},
    {"C525", "Cessna CitationJet", "Cessna CitationJet"},
    {"C550", "Cessna Citation II", "Cessna Citation II"},
    {"C560", "Cessna Citation V", "Cessna Citation V"},
    {"C650", "Cessna Citation III", "Cessna Citation III"},
    {"C680", "Cessna Citation Sovereign", "Cessna Citation Sovereign"},
    {"C68A", "Cessna Citation Latitude", "Cessna Citation Latitude"},
    {"C700", "Cessna Citation Longitude", "Cessna Citation Longitude"},
    {"GLEX", "Bombardier Global Express", "Bombardier Global Express"},
    {"GL5T", "Bombardier Global 5000", "Bombardier Global 5000"},
    {"GL7T", "Bombardier Global 7500", "Bombardier Global 7500"},
    {"GLF4", "Gulfstream IV", "Gulfstream IV"},
    {"GLF7", "Gulfstream G700", "Gulfstream G700"},
    {"H25B", "Hawker 800", "Hawker 800"},
    {"LJ35", "Learjet 35", "Learjet 35"},
    {"LJ60", "Learjet 60", "Learjet 60"},
    {"PC24", "Pilatus PC-24", "Pilatus PC-24"},
    {"C206", "Cessna 206", "Cessna 206"},
    {"C210", "Cessna 210", "Cessna 210"},
    {"PA34", "Piper PA-34 Seneca", "Piper PA-34 Seneca"},
    {"PA46", "Piper PA-46 Malibu", "Piper PA-46 Malibu"},
    {"SR20", "Cirrus SR20", "Cirrus SR20"},
    {"DA62", "Diamond DA62", "Diamond DA62"},
    {"DHC6", "De Havilland Canada DHC-6 Twin Otter", "De Havilland Canada DHC-6 Twin Otter"},
    {"DH8C", "De Havilland Canada Dash 8-300", "De Havilland Canada Dash 8-300"},
    {"AT45", "ATR 42-500", "ATR 42-500"},
    {"AT46", "ATR 42-600", "ATR 42-600"},
    {"F100", "Fokker 100", "Fokker 100"},
    {"F70", "Fokker 70", "Fokker 70"},
    {"AS50", "Eurocopter AS350", "Eurocopter AS350"},
    {"EC45", "Eurocopter EC145", "Eurocopter EC145"},
    {"A109", "Agusta A109", "Agusta A109"},
    {"A169", "Leonardo AW169", "Leonardo AW169"},
    {"R22", "Robinson R22", "Robinson R22"},
    {"R66", "Robinson R66", "Robinson R66"},
    {"B407", "Bell 407", "Bell 407"},
    {"S92", "Sikorsky S-92", "Sikorsky S-92"},
    {"B06", "Bell 206", "Bell 206"},
    {"B429", "Bell 429", "Bell 429"},
    {"A189", "Leonardo AW189", "Leonardo AW189"},
    {"C177", "Cessna 177 Cardinal", "Cessna 177 Cardinal"},
    {"P28R", "Piper PA-28R Arrow", "Piper PA-28R Arrow"},
    {"PA31", "Piper PA-31 Navajo", "Piper PA-31 Navajo"},
    {"AT43", "ATR 42-300", "ATR 42-300"},
    {"DH8A", "De Havilland Canada Dash 8-100", "De Havilland Canada Dash 8-100"},
    {"SB20", "Saab 2000", "Saab 2000"},
    {"JS41", "British Aerospace Jetstream 41", "British Aerospace Jetstream 41"},
};
inline const Entry* find(const char* type) {
    if (!type) return nullptr;
    const size_t length = std::strlen(type);
    if (length < 2 || length > 4) return nullptr;
    for (const auto& model : kModels) {
        bool matches = true;
        for (size_t i = 0; i < length; ++i) {
            if (!model.code[i] || std::toupper((unsigned char)type[i]) != model.code[i]) {
                matches = false; break;
            }
        }
        if (matches && model.code[length] == '\0') return &model;
    }
    return nullptr; // Don't guess an image for unknown type codes.
}
}
